# IAR project atomthreads-sample-iar.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105; ATOM_STACK_CHECKING
  ICCSTM8.CCDiagSuppress: Pa050
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; stm8-include; ..\..\kernel; ..\..\tests
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: atomthreads-sample-iar.srec
  ILINK.IlinkOutputFile: atomthreads.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  ICCSTM8.CCDefines: NDEBUG; STM8S105
  group kernel
    ../../kernel/: atom.h atomkernel.c atommutex.c atommutex.h atomqueue.c atomqueue.h atomsem.c atomsem.h atomtimer.c atomtimer.h
  group stm8
    ./: atomport-asm-iar.s atomport-private.h atomport-tests.h atomport.c atomport.h stm8s_conf.h tests-main.c uart.c uart.h
  group stm8-include
    stm8-include/: config.h STM8S105C6.h STM8S105K6.h STM8S207MB.h
  group tests
    ../../tests/: atomtests.h sem1.c
